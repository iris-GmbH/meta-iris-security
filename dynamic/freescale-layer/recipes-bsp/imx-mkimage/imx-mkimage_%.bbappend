# extend native, so that other recipes can depend on imx-mkimage-native
BBCLASSEXTEND = "native"
